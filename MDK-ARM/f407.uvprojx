# Keil uVision project f407.uvprojx, settings and files
target f407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx LV_LVGL_H_INCLUDE_SIMPLE,STM32F407xx,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..;../SYSTEM/sys;../SYSTEM/delay;../SYSTEM/usart;../BSP/LED;../BSP/LCD;../BSP/KEY;../BSP/SRAM;../BSP/TOUCH;../BSP/IIC;../BSP/24CXX;../Mid/LVGL/LVGL_SRC;../Mid/LVGL/LVGL_SRC/lvgl;../Mid/LVGL/LVGL_SRC/lvgl/src;../Mid/LVGL/LVGL_SRC/lvgl/examples/porting;../Mid/LVGL/APPS/gui_app/ui;../Mid/LVGL/APPS/demos;../Mid/LVGL/APPS/demos/widgets;../Mid/LVGL/APPS/demos/widgets/assets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User/BSP
    ../BSP/LED/: led.c
    ../BSP/LCD/: lcd.c
    ../BSP/KEY/: key.c
    ../BSP/SRAM/: sram.c
    ../BSP/TOUCH/: touch.c ctiic.c ft5206.c gt9xxx.c
    ../BSP/IIC/: myiic.c
    ../BSP/24CXX/: 24cxx.c
  group User/SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group Mid/lvgl/conf
    ../Mid/LVGL/LVGL_SRC/lvgl/: lv_conf.h lvgl.h
  group Mid/lvgl/example/porting
    ../Mid/LVGL/LVGL_SRC/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Mid/lvgl/src/core
    ../Mid/LVGL/LVGL_SRC/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Mid/lvgl/src/draw
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Mid/lvgl/src/extra
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/msg/: lv_msg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/led/: lv_led.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/list/: lv_list.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/span/: lv_span.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/widgets/win/: lv_win.c
    ../Mid/LVGL/LVGL_SRC/lvgl/src/extra/: lv_extra.c
  group Mid/lvgl/src/font
    ../Mid/LVGL/LVGL_SRC/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Mid/lvgl/src/hal
    ../Mid/LVGL/LVGL_SRC/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Mid/lvgl/src/misc
    ../Mid/LVGL/LVGL_SRC/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Mid/lvgl/src/widgets
    ../Mid/LVGL/LVGL_SRC/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Mid/gui_app
    ../Mid/LVGL/APPS/gui_app/ui/: ui.c ui.h
  group Mid/lvgl_demo
    ../Mid/LVGL/APPS/demos/: lv_demos.h
    ../Mid/LVGL/APPS/demos/widgets/: lv_demo_widgets.c lv_demo_widgets.h
    ../Mid/LVGL/APPS/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
software components: CMSIS:CORE 4.3.0
